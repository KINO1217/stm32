# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\fwlibs;..\config;..\drivers;..\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c
  group config
    ../config/: stm32f10x_conf.h clock_conf.c driver_conf.h
  group sys
    ../sys/: delay.c sys.h my_uart.c my_iic.c my_timer.c my_pwm.c my_adc.c
  group fwlibs
    ../fwlibs/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c stm32f10x_it.c core_cm3.c
